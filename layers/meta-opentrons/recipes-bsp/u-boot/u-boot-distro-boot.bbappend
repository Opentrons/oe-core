FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://boot.cmd.in"

