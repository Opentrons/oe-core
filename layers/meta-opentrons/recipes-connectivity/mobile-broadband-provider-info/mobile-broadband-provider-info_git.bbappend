SRC_URI = "git://gitlab.gnome.org/GNOME/mobile-broadband-provider-info.git;protocol=https;branch=main"
SRC_URI[sha256sum] = "b4e086835f3ad360b39dd314bc58d26cc758d111a6afd8ed833020d1ac915167"
