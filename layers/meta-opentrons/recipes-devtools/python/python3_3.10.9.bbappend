FILESEXTRAPATHS:prepend = "${THISDIR}/python3:"

SRC_URI:prepend = " file://python3-manifest.json "
