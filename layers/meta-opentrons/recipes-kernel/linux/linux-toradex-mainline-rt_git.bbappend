LINUX_VERSION ?= "6.1.120-rt47"
LINUX_REPO = "https://kernel.googlesource.com/pub/scm/linux/kernel/git/stable/linux.git"
