PACKAGECONFIG:append = " png wayland viv-fb gles2 egl gbm "
