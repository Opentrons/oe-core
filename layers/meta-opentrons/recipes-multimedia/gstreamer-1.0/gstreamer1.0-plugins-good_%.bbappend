PACKAGECONFIG:append = " v4l2 libv4l2 "
DEPENDS:append = " v4l-utils "
