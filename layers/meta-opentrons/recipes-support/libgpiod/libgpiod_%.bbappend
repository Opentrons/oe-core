PACKAGECONFIG_append = " python3"
