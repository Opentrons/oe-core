
FILESEXTRAPATHS:prepend := "${THISDIR}/nss:"
SRC_URI:append = "\
           file://0001-PATCH-Remove-eMudhra-emSign-Root-C1-0335a2a5b00585f9520f3664e0ec70085aee2e9.patch \
           file://0002-PATCH-Remove-eMudhra-emSign-Root-G3-ece6760d782544fb994b0dacee287a957029c800.patch \
           "
